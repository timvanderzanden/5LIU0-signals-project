<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\5LIU0-signals.ewp</path>
  </project>
  <batchBuild />
</workspace>
